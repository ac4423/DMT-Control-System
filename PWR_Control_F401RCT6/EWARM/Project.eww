<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PWR_Control_F401RT6.ewp</path>
  </project>
  <batchBuild />
</workspace>
